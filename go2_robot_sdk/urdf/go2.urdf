Commit message: try: current state

File: go2_robot_sdk/urdf/go2.urdf (robot description, URDF)
Before this commit: robot go2, 33 links, 32 joints
Links:
- removed link map
- removed link odom
Joints:
- removed joint map_joint
- removed joint odom_joint
